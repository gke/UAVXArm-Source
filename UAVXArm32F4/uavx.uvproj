# Keil uVision project uavx.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: uavx
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: alarms.c altitude.c analog.c as.c auto.c batt.c bb.c calib.c clocks.c control.c emu.c filters.c frsky.c gps.c i2c.c imu.c inertial.c isr.c launch.c leds.c mag.c mavlink.c mission.c mixer.c mpu6xxx.c nav.c outputs.c params.c rc.c serial.c sio.c spi.c spiflash.c stats.c stmflash.c telem.c temp.c tests.c tune.c uavxarm-v3-gke.c UAVX.h alarms.h altfilt.c altfilt.h altitude.h analog.h armflash.c armflash.h as.h auto.h batt.h bb.h calib.h clocks.h control.h defaults.h emu.h filters.h frsky.h gps.h i2c.h i2ceeprom.c i2ceeprom.h imu.h inertial.h isr.h leds.h mag.h magvar.h main.h misctypes.h mission.h mixer.h mpu6xxx.h mpu6050.h nav.h nvmem.c nvmem.h outputs.h params.h rc.h serial.h sio.h spi.h spiflash.h telem.h temp.h tests.h tune.h UAVXRevision.h UAVXRevisionSVN.h wind.c wind.h
  group board
    ./src/boards/: harness.c harness.h
    ./src/boards/targets/: discoveryf4.inc omnibusf4nxt.inc omnibusf4v1.inc targets.inc uavxf4v2.inc uavxf4v3.inc uavxf4v4.inc
  group lib
    ./lib/Std/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./lib/Std/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
    ./lib/Device/ST/STM32F4xx/Include/: core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h stm32f4xx.h system_stm32f4xx.h
    ./lib/CMSIS/inc/: arm_common_tables.h arm_math.h
    ./lib/CMSIS/src/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
    ./lib/CMSIS/src/BasicMathFunctions/: arm_abs_f32.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f32.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_dot_prod_f32.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mult_f32.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_negate_f32.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_offset_f32.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_scale_f32.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sub_f32.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c
    ./lib/CMSIS/src/CommonTables/: arm_common_tables.c
    ./lib/CMSIS/src/SupportFunctions/: arm_copy_f32.c arm_copy_q7.c arm_copy_q15.c arm_copy_q31.c arm_fill_f32.c arm_fill_q7.c arm_fill_q15.c arm_fill_q31.c arm_float_to_q7.c arm_float_to_q15.c arm_float_to_q31.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_q15_to_float.c arm_q15_to_q7.c arm_q15_to_q31.c arm_q31_to_float.c arm_q31_to_q7.c arm_q31_to_q15.c
